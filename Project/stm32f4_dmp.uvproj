# Keil uVision project stm32f4_dmp.uvproj, settings and files
target stm32f4_dmp (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: stm32f4_dmp
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER STM32F40_41xxx ARM_MATH_CM4 __FPU_PRESENT MPU9250
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Drivers\inc;..\Application\inc;..\Libraries\eMPL;..\Matrix\inc;..\Algorithm\inc;..\Math\inc;..\miniIMU;..\miniIMU\FP;..\miniAHRS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Application/Src/: stm32f4_delay.c stm32f4_exti.c stm32f4_mpu9250.c main.c system_stm32f4xx.c stm32f4_rcc.c
    ../Application/src/: stm32f4_serial.c stm32f4_string.c stm32f4_ms5611.c stm32f4_gps.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c misc.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group eMPL
    ../Libraries/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Algorithm
    ../Algorithm/src/: EKF.c UKF.c Quaternion.c Control.c PID.c INS_EKF.c SRCKF.c CKF.C
  group Matrix
    ../Matrix/src/: Matrix.c
  group DSP_Lib
    ../Libraries/CMSIS/DSP_Lib/Lib/: arm_cortexM4lf_math.lib
  group Drivers
    ../Drivers/src/: stm32f4_spi.c stm32f4_usart.c
  group Math
    ../Math/src/: FastMath.c
  group miniIMU
    ../miniIMU/: miniIMU.c miniMatrix.c
  group FP_miniIMU
    ../miniIMU/FP/: FP_Matrix.c FP_miniIMU.c FP_Math.c
  group miniAHRS
    ../miniAHRS/: miniAHRS.c
